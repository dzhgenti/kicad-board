# Repository dzhgenti/kicad-board

File README.md:

View this project on [CADLAB.io](https://b1238a28.cadlabapp.com/project/1). 

# kicad-board

## KiCad design pic_programmer.kicad_pcb

Parts:
C1: 100µF; CP_Axial_L18.0mm_D6.5mm_P25.00mm_Horizontal
C2: 220uF; CP_Axial_L18.0mm_D6.5mm_P25.00mm_Horizontal; PartNumber 12345
C3: 22uF/25V; C_Axial_L12.0mm_D6.5mm_P20.00mm_Horizontal
C4: 0; C_Disc_D5.1mm_W3.2mm_P5.00mm
C5: 10nF; C_Disc_D5.1mm_W3.2mm_P5.00mm
C9: 220nF; C_Disc_D5.1mm_W3.2mm_P5.00mm
D1: 1N4004; D_DO-35_SOD27_P12.70mm_Horizontal
D2, D3, D4, D5, D6, D7, D11: BAT43; D_DO-35_SOD27_P7.62mm_Horizontal
D8: RED-LED; LED_D5.0mm
D9: GREEN-LED; LED_D5.0mm
D10: SCHOTTKY; D_DO-35_SOD27_P12.70mm_Horizontal
D12: YELLOW-LED; LED_D5.0mm
J1: DB9-FEMAL; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_H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
JP1: JUMPER; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
L1: 22uH; L_Radial_D7.8mm_P5.00mm_Fastron_07HCP
P1: CONN_2; Altech_AK300_1x02_P5.00mm_45-Degree
P101, P102, P103, P104, P105, P106: CONN_1; MountingHole_4.3mm_M4
Q1: BC237; TO-92
Q2, Q3: BC307; TO-92
R1, R2, R3, R4, R5, R6, R7: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R19, R20: 2.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R10: 5,1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11, R17: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R12, R13, R21: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R14: 47; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R15: 6.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R16: 62K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R18: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1: 1K; RV2X4
U2: 74HC125; DIP-14_W7.62mm_LongPads
U3: 7805; TO-220-3_Horizontal_TabDown
U4: LT1373; DIP-8_W7.62mm_LongPads
U7: 4075

Connections:
/CLOCK-RB6: R13.2; also elsewhere on the board
/DATA-RB7: R12.2, U2.12; also elsewhere on the board
/PC-CLOCK-OUT: J1.7, R5.1, R6.1
/PC-DATA-IN: J1.8, U2.11
/PC-DATA-OUT: J1.4, R3.1, R4.1
/VCC_PIC: JP1.2, Q3.1 (C), R21.2; also elsewhere on the board
/VPP/MCLR: R18.2; also elsewhere on the board
/VPP_ON: J1.3, R1.1, R2.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D3.2 (A), D5.2 (A), D7.2 (A), D8.1 (K), D9.1 (K), D12.1 (K), J1.5, P1.1, Q1.3 (E), R2.2, R4.2, R6.2, R15.2, R17.2, U2.1, U2.4, U2.7 (GND), U2.10, U2.13, U3.2 (GND), U4.6 (GND_S), U4.7 (GND); also elsewhere on the board
unnamed: C2.1, D1.1 (K), U3.1 (VI)
unnamed: C4.1, R10.1, U4.1 (Vc)
unnamed: C5.1, R10.2
unnamed: C9.2, Q2.2 (B), R7.2, R11.2
unnamed: D1.2 (A), P1.2 (PM)
unnamed: D2.2 (A), D3.1 (K), R1.2, U2.2
unnamed: D4.2 (A), D5.1 (K), R3.2, U2.5
unnamed: D6.2 (A), D7.1 (K), R5.2, U2.9
unnamed: D8.2 (A), R9.2
unnamed: D9.2 (A), R14.2
unnamed: D10.2 (A), L1.1, U4.8 (Vsw)
unnamed: D11.1 (K), Q1.1 (C), R11.1
unnamed: D11.2 (A), R19.1
unnamed: D12.2 (A), R21.1
unnamed: Q1.2 (B), R8.2
unnamed: Q2.1 (C), R9.1, R17.1, R18.1
unnamed: Q3.2 (B), R19.2, R20.2
unnamed: R8.1, U2.3
unnamed: R12.1, U2.6
unnamed: R13.1, U2.8
unnamed: R15.1, RV1.1
unnamed: R16.1, RV1.3
unnamed: RV1.2, U4.2 (FB+)
VCC: C1.1, D2.1 (K), D4.1 (K), D6.1 (K), JP1.1, L1.2, Q3.3 (E), R14.1, R20.1, U2.14 (VCC), U3.3 (VO), U4.5 (Vin)
VPP: C3.1, C9.1, D10.1 (K), Q2.3 (E), R7.1, R16.2

Notes on the sheet:
8 to 15V
DTR
VPP (13V) power
Mounting holes
TXD
ADJUST for VPP = 13V
CTS
RTS

Parts:
C6, C7: 100nF; C_Disc_D5.1mm_W3.2mm_P5.00mm
P2: SUPP28; DIP-28_W7.62mm_Socket_LongPads
P3: SUPP40; 40tex-Ell600
U1: 24Cxx; DIP-8_W7.62mm_Socket_LongPads
U5: PIC_18_PINS; DIP-18_W7.62mm_Socket_LongPads
U6: PIC_8_PINS; DIP-8_W7.62mm_Socket_LongPads

Connections:
/CLOCK-RB6: P2.27, P3.39, U1.6 (SCL), U5.12 (ICSPC/RB6), U6.6 (GP1); also elsewhere on the board
/DATA-RB7: P2.28, P3.40, U1.5 (SDA), U5.13 (ICSPD/RB7), U6.7 (GP0); also elsewhere on the board
/VCC_PIC: C6.1, C7.1, P2.20, P3.11, P3.32, U1.8 (VCC), U5.14 (VDD), U6.1 (VDD); also elsewhere on the board
/VPP/MCLR: P2.1, P3.1, U5.4 (MCLR), U6.4 (GP3/MCLR); also elsewhere on the board
GND: C6.2, C7.2, P2.8, P2.19, P3.8, P3.12, P3.31, U1.1 (A0), U1.2 (A1), U1.3 (A2), U1.4 (GND), U5.5 (VSS), U6.8 (VSS); also elsewhere on the board

Board: 4 copper layers, 160.0 x 99.1 mm, 63 parts (1 on the bottom side), 34 nets.

## Commit log (part)

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2026-05-15 files added
2026-05-15 layout changes
2026-05-21 Backlink to CADLAB.io has been added.
